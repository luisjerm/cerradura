# Keil uVision project SD_Example.uvproj, settings and files
target SD_Example (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: SD_Example
  c flags: Optim=1
  c define: __UART0
  c include: ..\USER;..\Libraries\CM3\CoreSupport;..\Libraries\CM3\DeviceSupport\NXP\LPC17xx;..\Libraries\LPC1700CMSIS_Firmware_Library\include;..\USER\GLCD;..\USER\TouchPanel;..\USER\MFRC522;..\Libraries\RTL
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group StartUp
    ../Libraries/CM3/DeviceSupport/NXP/LPC17xx/startup/arm/: startup_LPC17xx.s
    ../Libraries/CM3/DeviceSupport/NXP/LPC17xx/: system_LPC17xx.c
    ../Libraries/CM3/CoreSupport/: core_cm3.c
  group LPC17xx_Lib
    ../Libraries/LPC1700CMSIS_Firmware_Library/source/: lpc17xx_wdt.c debug_frmwrk.c lpc17xx_adc.c lpc17xx_can.c lpc17xx_clkpwr.c lpc17xx_dac.c lpc17xx_emac.c lpc17xx_exti.c lpc17xx_gpdma.c lpc17xx_gpio.c lpc17xx_i2c.c lpc17xx_i2s.c lpc17xx_libcfg_default.c lpc17xx_mcpwm.c lpc17xx_nvic.c lpc17xx_pinsel.c lpc17xx_pwm.c lpc17xx_qei.c lpc17xx_rit.c lpc17xx_rtc.c lpc17xx_spi.c lpc17xx_ssp.c lpc17xx_systick.c lpc17xx_timer.c lpc17xx_uart.c
  group GLCD
    ../USER/GLCD/: AsciiLib.c GLCD.c
  group TouchPanel
    ../USER/TouchPanel/: TouchPanel.c
  group File
    ../Libraries/RTL/: File_Config.c FS_CM3.lib SPI_LPC17xx.c Retarget.c
  group Source
    ../USER/: main.c menu.c SD_Functions.c timer.c rtc.c ventilador.c alarma.c pantalla.c tecladoM.c ADC.c uart.c uart.h
    ./: tarjetaRFID.c
  group Documentation
    ./: readme.txt
  group MFRC522
    ../USER/MFRC522/: MFRC522.c RFID.c
